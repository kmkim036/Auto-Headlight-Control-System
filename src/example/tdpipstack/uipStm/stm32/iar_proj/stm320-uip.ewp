# IAR project stm320-uip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\src\; ..\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; ..\..\lib\; ..\..\uip\; ..\..\apps\hello-world\; ..\..\apps\webclient\; ..\..\apps\resolv\; ..\..\apps\httpd\; ..\..\apps\yeelink\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm320-uip.srec
  ILINK.IlinkOutputFile: stm320-uip.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps/hello-world
    ../../apps/hello-world/: hello-world.c hello-world.h
  group apps/httpd
    ../../apps/httpd/: httpd.c httpd.h
  group apps/resolv
    ../../apps/resolv/: resolv.c resolv.h
  group apps/web-client
    ../../apps/webclient/: webclient-strings.c webclient-strings.h webclient.c webclient.h
  group apps/yeelink
    ../../apps/yeelink/: yeelink-client.c yeelink-client.h
  group lib
    ../../lib/: memb.c memb.h
  group stm32/libraries/inc
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group stm32/libraries/src
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group stm32/startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group stm32/usr/inc
    ../src/: app_call.h clock-arch.h enc28j60.h stm32f10x_conf.h stm32f10x_it.h tapdev.h uart.h uip-conf.h
  group stm32/usr/src
    ../src/: app_call.c clock-arch.c enc28j60.c main.c stm32f10x_it.c system_stm32f10x.c tapdev.c uart.c
  group uip/inc
    ../../uip/: clock.h lc-addrlabels.h lc-switch.h lc.h psock.h pt.h uip-neighbor.h uip.h uip_arch.h uip_arp.h uip_timer.h uiplib.h uipopt.h
  group uip/src
    ../../uip/: psock.c uip-neighbor.c uip.c uip_arp.c uip_timer.c uiplib.c
