# Keil uVision project stm32-uip.uvproj, settings and files
target stm32-uip (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-uip
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\src;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\lib;..\..\uip;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\apps\hello-world
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h stm32f10x.h
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../src/: clock-arch.c main.c clock-arch.h uip-conf.h stm32f10x_conf.h system_stm32f10x.c stm32f10x_it.c uart.c
  group Uip
    ../../uip/: psock.c uip.c uip_arp.c uip_timer.c uip-fw.c uiplib.c
  group Dev
    ../src/: tapdev.c enc28j60.c
  group Apps
    ../src/: app_call.c
    ../../apps/hello-world/: hello-world.c
